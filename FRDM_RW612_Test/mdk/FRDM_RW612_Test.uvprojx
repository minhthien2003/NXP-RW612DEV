# Keil uVision project FRDM_RW612_Test.uvprojx, settings and files
target flash_debug (6240000::V6.24::ARMCLANG)
  device: RW612ETA2I NXP
  pack: NXP.RW612_DFP.25.12.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ
  output: FRDM_RW612_Test +hex
  AfterMake: fromelf --bincombined --output=".\Objects\FRDM_RW612_Test.bin" "#L"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_RW612ETA2I,RW612_SERIES,DEBUG,MCUX_META_BUILD,MCUXPRESSO_SDK,BOOT_HEADER_ENABLE=1,SDK_DEBUGCONSOLE=1
  c misc: -include "../config/mcux_config.h" -include "../config/mcuxsdk_version.h" -mcpu=cortex-m33+nodsp -mfpu=fpv5-sp-d16 -ffunction-sections -fdata-sections -fno-common -fno-builtin
  c include: ..\board;..\config;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\devices\Wireless\RW\RW612;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\devices\Wireless\RW\periph;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\devices\Wireless\RW\RW612\drivers;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\arch\arm\CMSIS\Core\Include;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\arch\arm\CMSIS\Core\Include\m-profile;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\examples\_boards\frdmrw612\flash_config;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\common;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\flexcomm;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\flexspi;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\lpc_gpio;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\cache\cache64;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\drivers\flexcomm\usart;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\assert;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\debug_console_lite;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\str;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\uart;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClBuffer\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClBuffer\inc\internal;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClCore\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClEls\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClEls\inc\internal;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClMemory\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxClMemory\inc\internal;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslMemory\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslMemory\inc\internal;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslCPreProcessor\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslDataIntegrity\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslFlowProtection\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslParamIntegrity\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\comps\mcuxCsslSecureCounter\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\compiler;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\platforms\rw61x;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\src\platforms\rw61x\inc;..\..\..\MCUXpresso\mcuxpresso-sdk\mcuxsdk\components\els_pkc\includes\platform\rw61x
  asm define: CPU_RW612ETA2I,RW612_SERIES,MCUXPRESSO_SDK
  asm misc: -include "../config/mcux_config.h" -include "../config/mcuxsdk_version.h" -mcpu=cortex-m33+nodsp -mfpu=fpv5-sp-d16
  asm include: as above
  memory RVCT1: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x130000
  scatter file: ..\linker\RW612_flash.scf
  link misc: --remove --entry=Reset_Handler --strict --diag_suppress=6314 --cpu=Cortex-M33.no_dsp --fpu=FPv5-SP
  group Device
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/devices/Wireless/RW/RW612/: system_RW612.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/devices/Wireless/RW/RW612/arm/: startup_RW612.S
  group SDK drivers
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/devices/Wireless/RW/RW612/drivers/: fsl_clock.c fsl_i2s_bridge.c fsl_iped.c fsl_ocotp.c fsl_power.c fsl_reset.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/common/: fsl_common.c fsl_common_arm.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/flexcomm/: fsl_flexcomm.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/flexspi/: fsl_flexspi.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/lpc_gpio/: fsl_gpio.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/cache/cache64/: fsl_cache.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/drivers/flexcomm/usart/: fsl_usart.c
  group Boot header
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/examples/_boards/frdmrw612/flash_config/: flash_config.c
  group Board
    ../board/: board.c clock_config.c pin_mux.c hardware_init.c
  group SDK components
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/assert/: fsl_assert.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/debug_console_lite/: fsl_debug_console.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/misc_utilities/: fsl_memcpy.S fsl_memset.S
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/str/: fsl_str.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/uart/: fsl_adapter_usart.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/els_pkc/src/comps/mcuxClBuffer/src/: mcuxClBuffer.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/els_pkc/src/comps/mcuxClEls/src/: mcuxClEls_Common.c mcuxClEls_GlitchDetector.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/els_pkc/src/comps/mcuxClMemory/src/: mcuxClMemory.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/els_pkc/src/comps/mcuxCsslMemory/src/: mcuxCsslMemory_Clear.c mcuxCsslMemory_Compare.c mcuxCsslMemory_Copy.c mcuxCsslMemory_Set.c
    ../../../MCUXpresso/mcuxpresso-sdk/mcuxsdk/components/els_pkc/src/comps/mcuxCsslParamIntegrity/src/: mcuxCsslParamIntegrity32.c
  group Application
    ../source/: main.c
