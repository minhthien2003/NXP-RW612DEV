<?xml version='1.0' encoding='utf-8'?>
<ProjectWorkspace>
  <SchemaVersion>1.0</SchemaVersion>
  <project>
    <PathAndName>.\FRDM_RW612_Test.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
    <NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild>
  </project>
</ProjectWorkspace>